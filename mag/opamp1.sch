v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {pmocs.sym} -50 -30 0 0 {name=x1}
C {nmoscs.sym} 370 -30 0 1 {name=x2}
C {pmos_diffamp.sym} -50 100 0 0 {name=x3}
C {nmos_diffamp.sym} 380 90 0 1 {name=x4}
C {devices/lab_pin.sym} 220 0 0 0 {name=p1 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 100 -60 0 1 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 230 110 0 0 {name=p3 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 100 90 0 1 {name=p4 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 100 -20 0 1 {name=p5 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 100 0 0 1 {name=p6 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 220 -40 0 0 {name=p7 sig_type=std_logic lab=net1}
C {devices/lab_pin.sym} 220 -60 0 0 {name=p8 sig_type=std_logic lab=net2}
C {devices/lab_pin.sym} 220 -20 0 0 {name=p9 sig_type=std_logic lab=RS}
C {devices/lab_pin.sym} 100 -40 0 1 {name=p10 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 100 130 0 1 {name=p11 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 230 70 0 0 {name=p12 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 230 90 0 0 {name=p13 sig_type=std_logic lab=net4}
C {devices/lab_pin.sym} -200 70 0 0 {name=p14 sig_type=std_logic lab=VIN}
C {devices/lab_pin.sym} -200 90 0 0 {name=p15 sig_type=std_logic lab=VIP}
C {devices/lab_pin.sym} 100 70 0 1 {name=p16 sig_type=std_logic lab=net3}
C {devices/lab_pin.sym} 100 110 0 1 {name=p17 sig_type=std_logic lab=net4}
C {devices/iopin.sym} -320 -160 0 1 {name=p18 lab=VDD}
C {devices/iopin.sym} -320 -120 0 1 {name=p19 lab=GND}
C {devices/iopin.sym} -320 -80 0 1 {name=p20 lab=OUT}
C {devices/iopin.sym} -320 -40 0 1 {name=p21 lab=RS}
C {devices/iopin.sym} -320 0 0 1 {name=p22 lab=VIN}
C {devices/iopin.sym} -320 40 0 1 {name=p23 lab=VIP}
